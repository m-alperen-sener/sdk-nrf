## tests/bluetooth/tester/boards/nrf54l15dk_nrf54l15_cpuapp.conf
```kconfig
CONFIG_ZMS=y
CONFIG_SYSTEM_WORKQUEUE_STACK_SIZE=2560
CONFIG_BT_RX_STACK_SIZE=3072
```
